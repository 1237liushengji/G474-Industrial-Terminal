# Keil uVision project G474.uvprojx, settings and files
target A_GW_M1 (6140000::V6.14::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: A_GW_M1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,NODE_ROLE=0,FORM_MODE=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\App;..\BSP;..\Common;..\Protocol;..\Storage;..\Gateway;..\Network;..\Network\mqttc\include;..\Middlewares\FreeRTOS-Kernel\include;..\Middlewares\FreeRTOS-Kernel\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../BSP/: bsp_uart.c bsp_rs485.c bsp_tick.c bsp_eeprom.c bsp_lcd.c bsp_key.c bsp_w25q128.c bsp_led.c bsp_iwdg.c can_drv.c bsp_console.c
  group Storage
    ../Storage/: config.c log.c log_service.c
  group Common
    ../Common/: ring_buffer.c bsp_printf.c console.c dp_table.c fmt.c
  group Protocol
    ../Protocol/: modbus_crc.c modbus_register.c modbus_slave.c modbus_master.c isotp.c uds.c
  group App
    ../App/: mb_master_port.c node_app.c app_rtos.c
    ../BSP/: bsp_board_assert.c
  group Gateway
    ../Gateway/: can_router.c bridge.c uplink_port.c uplink_fmt.c gw_ui.c
  group Network
    ../Network/: esp_at.c at_window.c mqtt_client.c backfill.c
  group Network/mqttc
    ../Network/mqttc/src/: mqtt.c
  group Middlewares/FreeRTOS-Kernel
    ../Middlewares/FreeRTOS-Kernel/: tasks.c list.c queue.c
    ../Middlewares/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
target A_GW_M2 (6140000::V6.14::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: as above
  output: A_GW_M2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,NODE_ROLE=0,FORM_MODE=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target B_NODE_M1 (6140000::V6.14::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: as above
  output: B_NODE_M1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,NODE_ROLE=1,FORM_MODE=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target B_NODE_M2 (6140000::V6.14::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: as above
  output: B_NODE_M2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,NODE_ROLE=1,FORM_MODE=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.6.0
